## tests/midi1_parser/testcase.yaml
```yaml
tests:
  midi.midi1_parser:
    platform_allow: frdm_mcxc242
    tags: midi parser
    timeout: 60
```
